# file: LAB_1.ioc
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Mcu.Family=STM32F1
Mcu.Name=STM32F103C(4-6)Tx
Mcu.Package=LQFP48
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
PA5.GPIO_Label=NORTH_RED
PA5.Signal=GPIO_Output
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=CMake
RCC.APB1Freq_Value=8000000
RCC.APB2Freq_Value=8000000
VP_SYS_VS_ND.Mode=No_Debug
board=custom

// file: Core/Src/main.c
/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.c
  * @brief          : Main program body
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2026 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/* USER CODE END Header */
#include "main.h"

/* USER CODE BEGIN PD */

#define ALL_TRAFFIC_LED_PINS (SOUTH_RED_Pin | SOUTH_YELLOW_Pin | \
                              SOUTH_GREEN_Pin | EAST_RED_Pin | \
                              EAST_YELLOW_Pin | NORTH_RED_Pin | \
                              NORTH_YELLOW_Pin | NORTH_GREEN_Pin | \
                              EAST_GREEN_Pin | WEST_RED_Pin | \
                              WEST_YELLOW_Pin | WEST_GREEN_Pin)

#define ALL_SEGMENT_PINS (SEG_A_Pin | SEG_B_Pin | SEG_C_Pin | SEG_D_Pin | \
                          SEG_E_Pin | SEG_F_Pin | SEG_G_Pin)

/* USER CODE END PD */

void SystemClock_Config(void);
static void MX_GPIO_Init(void);
/* USER CODE BEGIN PFP */

void display7SEG(int num);
static void TrafficLight_Set(uint16_t active_pins);

/* USER CODE END PFP */

int main(void)
{

  /* USER CODE BEGIN 1 */

  uint8_t traffic_state = 0;
  uint8_t remaining_seconds = 3;

  /* USER CODE END 1 */

  /* MCU Configuration--------------------------------------------------------*/

  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
  HAL_Init();

  /* Configure the system clock */
  SystemClock_Config();

  /* Initialize all configured peripherals */
  MX_GPIO_Init();
  /* USER CODE BEGIN 2 */

  /* All LEDs are active-low, so a high output turns every LED off. */
  HAL_GPIO_WritePin(GPIOA, ALL_TRAFFIC_LED_PINS, GPIO_PIN_SET);
  HAL_GPIO_WritePin(GPIOB, ALL_SEGMENT_PINS, GPIO_PIN_SET);

  /* USER CODE END 2 */

  /* Infinite loop */
  while (1)
  {

    /* USER CODE BEGIN 3 */
    switch (traffic_state)
    {
      case 0:
        TrafficLight_Set(NORTH_GREEN_Pin | SOUTH_GREEN_Pin |
                         EAST_RED_Pin | WEST_RED_Pin);
        break;

      case 1:
        TrafficLight_Set(NORTH_YELLOW_Pin | SOUTH_YELLOW_Pin |
                         EAST_RED_Pin | WEST_RED_Pin);
        break;

      case 2:
        TrafficLight_Set(NORTH_RED_Pin | SOUTH_RED_Pin |
                         EAST_GREEN_Pin | WEST_GREEN_Pin);
        break;

      default:
        TrafficLight_Set(NORTH_RED_Pin | SOUTH_RED_Pin |
                         EAST_YELLOW_Pin | WEST_YELLOW_Pin);
        break;
    }

    display7SEG(remaining_seconds);
    HAL_Delay(1000);

    --remaining_seconds;
    if (remaining_seconds == 0)
    {
      traffic_state = (traffic_state + 1U) % 4U;
      remaining_seconds = ((traffic_state % 2U) == 0U) ? 3U : 2U;
    }
  }
  /* USER CODE END 3 */
}

void SystemClock_Config(void)
{
  RCC_OscInitTypeDef RCC_OscInitStruct = {0};
  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

  /** Initializes the RCC Oscillators according to the specified parameters
  * in the RCC_OscInitTypeDef structure.
  */
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSI;
  RCC_OscInitStruct.HSIState = RCC_HSI_ON;
  RCC_OscInitStruct.HSICalibrationValue = RCC_HSICALIBRATION_DEFAULT;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_NONE;
  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    Error_Handler();
  }

  /** Initializes the CPU, AHB and APB buses clocks
  */
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
                              |RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_HSI;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV1;
  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV1;

  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_0) != HAL_OK)
  {
    Error_Handler();
  }
}

static void MX_GPIO_Init(void)
{
  GPIO_InitTypeDef GPIO_InitStruct = {0};

  /* GPIO Ports Clock Enable */
  __HAL_RCC_GPIOA_CLK_ENABLE();
  __HAL_RCC_GPIOB_CLK_ENABLE();

  /*Configure GPIO pin Output Level */
  HAL_GPIO_WritePin(GPIOA, SOUTH_RED_Pin|SOUTH_YELLOW_Pin|SOUTH_GREEN_Pin|EAST_RED_Pin
                          |EAST_YELLOW_Pin|NORTH_RED_Pin|NORTH_YELLOW_Pin|NORTH_GREEN_Pin
                          |EAST_GREEN_Pin|WEST_RED_Pin|WEST_YELLOW_Pin|WEST_GREEN_Pin, GPIO_PIN_RESET);

  /*Configure GPIO pin Output Level */
  HAL_GPIO_WritePin(GPIOB, SEG_A_Pin|SEG_B_Pin|SEG_C_Pin|SEG_D_Pin
                          |SEG_E_Pin|SEG_F_Pin|SEG_G_Pin, GPIO_PIN_SET);

  /*Configure GPIO pins : SOUTH_RED_Pin SOUTH_YELLOW_Pin SOUTH_GREEN_Pin EAST_RED_Pin
                           EAST_YELLOW_Pin NORTH_RED_Pin NORTH_YELLOW_Pin NORTH_GREEN_Pin
                           EAST_GREEN_Pin WEST_RED_Pin WEST_YELLOW_Pin WEST_GREEN_Pin */
  GPIO_InitStruct.Pin = SOUTH_RED_Pin|SOUTH_YELLOW_Pin|SOUTH_GREEN_Pin|EAST_RED_Pin
                          |EAST_YELLOW_Pin|NORTH_RED_Pin|NORTH_YELLOW_Pin|NORTH_GREEN_Pin
                          |EAST_GREEN_Pin|WEST_RED_Pin|WEST_YELLOW_Pin|WEST_GREEN_Pin;
  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_LOW;
  HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);

  /*Configure GPIO pins : SEG_A_Pin SEG_B_Pin SEG_C_Pin SEG_D_Pin
                           SEG_E_Pin SEG_F_Pin SEG_G_Pin */
  GPIO_InitStruct.Pin = SEG_A_Pin|SEG_B_Pin|SEG_C_Pin|SEG_D_Pin
                          |SEG_E_Pin|SEG_F_Pin|SEG_G_Pin;
  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_LOW;
  HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);

}

/* USER CODE BEGIN 4 */

/**
  * @brief Display one digit on the active-low common-anode 7-segment LED.
  * @param num Digit from 0 to 9. Other values turn all segments off.
  */
void display7SEG(int num)
{
  static const uint16_t digit_segments[10] = {
    SEG_A_Pin | SEG_B_Pin | SEG_C_Pin | SEG_D_Pin | SEG_E_Pin | SEG_F_Pin,
    SEG_B_Pin | SEG_C_Pin,
    SEG_A_Pin | SEG_B_Pin | SEG_D_Pin | SEG_E_Pin | SEG_G_Pin,
    SEG_A_Pin | SEG_B_Pin | SEG_C_Pin | SEG_D_Pin | SEG_G_Pin,
    SEG_B_Pin | SEG_C_Pin | SEG_F_Pin | SEG_G_Pin,
    SEG_A_Pin | SEG_C_Pin | SEG_D_Pin | SEG_F_Pin | SEG_G_Pin,
    SEG_A_Pin | SEG_C_Pin | SEG_D_Pin | SEG_E_Pin | SEG_F_Pin | SEG_G_Pin,
    SEG_A_Pin | SEG_B_Pin | SEG_C_Pin,
    ALL_SEGMENT_PINS,
    SEG_A_Pin | SEG_B_Pin | SEG_C_Pin | SEG_D_Pin | SEG_F_Pin | SEG_G_Pin
  };

  HAL_GPIO_WritePin(GPIOB, ALL_SEGMENT_PINS, GPIO_PIN_SET);

  if ((num >= 0) && (num <= 9))
  {
    HAL_GPIO_WritePin(GPIOB, digit_segments[num], GPIO_PIN_RESET);
  }
}

/**
  * @brief Turn on only the selected active-low traffic LEDs.
  * @param active_pins GPIOA mask of LEDs that must be on.
  */
static void TrafficLight_Set(uint16_t active_pins)
{
  HAL_GPIO_WritePin(GPIOA, ALL_TRAFFIC_LED_PINS, GPIO_PIN_SET);
  HAL_GPIO_WritePin(GPIOA, active_pins, GPIO_PIN_RESET);
}

/* USER CODE END 4 */

void Error_Handler(void)
{
  __disable_irq();
  while (1)
  {
  }
}
